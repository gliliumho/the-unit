# Keil uVision project testTwoWay.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF9E5 Multiband Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: testTwoWay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../source/: main.c
    ../../library/uVision/: libnrf9e5.LIB
