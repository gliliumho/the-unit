# Keil uVision project masterRF.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF9E5 Multiband Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: masterRF +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: main_master.c
    ../../library/uVision/Objects/: libnrf9e5.LIB
