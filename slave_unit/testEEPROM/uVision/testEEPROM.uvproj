# Keil uVision project testEEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF9E5 Multiband Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: testEEPROM +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51
    ../source/: main.c libnrf9e5.LIB
