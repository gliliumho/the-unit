# Keil uVision project libnrf9e5.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF9E5 Multiband Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(16000000) MODDP2
  output: libnrf9e5 (library)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: eeprom.c misc.c radio.c radio_extra.c radio_master.c radio_slave.c uart.c util.c
